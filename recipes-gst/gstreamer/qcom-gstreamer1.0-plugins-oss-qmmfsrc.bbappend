CAMERA_METADATA_VERSION              := "1.1"
