FILESEXTRAPATHS:prepend:qcom := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-PFR-sensor-cdev-node.patch \
"
